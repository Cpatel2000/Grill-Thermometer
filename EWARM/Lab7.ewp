# IAR project Lab7.ewp, settings and files
configuration Lab7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070RB ST STM32G070RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G070xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\SSD1306\OLED\Inc; ..\Core\Modules\Conversions; ..\Core\Modules\KeyboardHoldRepeat; ..\Core\Modules\Serial; ..\Core\Modules\UX; ..\Core\Modules\thermocouple; C:\Users\Admin\Desktop\Lab7\Core\Modules\Thermistor10k
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab7.hex
  ILINK.IlinkOutputFile: Lab7.out
  ILINK.IlinkIcfFile: stm32g070xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/Modules
    ../Core/Modules/Conversions/: ASCII_numbers.c
    ../Core/Modules/KeyboardHoldRepeat/: KeyboardHoldRepeat.c KeyboardHoldRepeat_User.c
    ../Core/Modules/Serial/: Serial.c serial_user.c
    ../Core/Modules/Thermistor10k/: thermistor.c
    ../Core/Modules/thermocouple/: thermocouple.c thermocouple.h
    ../Core/Modules/UX/: ux_manager.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/SSD1306
    ../Drivers/SSD1306/OLED/Src/: fonts.c ssd1306.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c
